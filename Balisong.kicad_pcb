# Repository liwei1997/Balisong

## KiCad design Balisong.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7, C8: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: SOD_123; D_SOD-123
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
R1, R2: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW25, SW29, SW49: MX; SW_Cherry_MX_1.50u_PCB
SW2, SW4, SW8, SW12, SW24, SW28, SW44, SW48, SW50, SW52: MX; SW_Cherry_MX_1.25u_PCB
SW3, SW5, SW6, SW7, SW9, SW10, SW11, SW13, SW14, SW15, SW16, SW17, SW18, SW20, SW21, SW22, SW23, SW26, SW27, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW38, SW39, SW40, SW41, SW42, SW43, SW45, SW46, SW47, SW51: MX; SW_Cherry_MX_1.00u_PCB
SW19, SW37: MX; SW_Cherry_MX_2.75u_PCB
SW53: SW_Push; SW_SPST_B3U-1000P
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm_HandSoldering

Connections:
COL0: SW1.2, SW2.2, SW3.2, SW4.2, U1.32 (PC7)
COL1: SW5.2, SW6.2, SW7.2, SW8.2, U1.31 (PC6)
COL2: SW9.2, SW10.2, SW11.2, SW12.2, U1.30 (PB6)
COL3: SW13.2, SW14.2, SW15.2, U1.29 (PB5)
COL4: SW16.2, SW17.2, SW18.2, SW19.2, U1.28 (PB4)
COL5: SW20.2, SW21.2, SW22.2, U1.27 (PD7)
COL6: SW23.2, SW24.2, SW25.2, SW26.2, U1.26 (PD6)
COL7: SW27.2, SW28.2, SW29.2, SW30.2, U1.1 (PE6)
COL8: SW31.2, SW32.2, SW33.2, U1.41 (PF0)
COL9: SW34.2, SW35.2, SW36.2, SW37.2, U1.40 (PF1)
COL10: SW38.2, SW39.2, SW40.2, U1.39 (PF4)
COL11: SW41.2, SW42.2, SW43.2, SW44.2, U1.38 (PF5)
COL12: SW45.2, SW46.2, SW47.2, SW48.2, U1.37 (PF6)
COL13: SW49.2, SW50.2, SW51.2, SW52.2, U1.36 (PF7)
D+: R3.1, U1.4 (D+)
D-: R4.1, U1.3 (D-)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.1, C8.1, J1.5 (GND), R1.1, SW53.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND)
unnamed: C5.1, U1.6 (UCAP)
unnamed: C7.2, U1.17 (XTAL1), Y1.1
unnamed: C8.2, U1.16 (XTAL2), Y1.2
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: D37.2 (A), SW37.1
unnamed: D38.2 (A), SW38.1
unnamed: D39.2 (A), SW39.1
unnamed: D40.2 (A), SW40.1
unnamed: D41.2 (A), SW41.1
unnamed: D42.2 (A), SW42.1
unnamed: D43.2 (A), SW43.1
unnamed: D44.2 (A), SW44.1
unnamed: D45.2 (A), SW45.1
unnamed: D46.2 (A), SW46.1
unnamed: D47.2 (A), SW47.1
unnamed: D48.2 (A), SW48.1
unnamed: D49.2 (A), SW49.1
unnamed: D50.2 (A), SW50.1
unnamed: D51.2 (A), SW51.1
unnamed: D52.2 (A), SW52.1
unnamed: J1.2 (D-), R4.2
unnamed: J1.3 (D+), R3.2
unnamed: R1.2, U1.33 (~HWB~/PE2)
unnamed: R2.2, SW53.2, U1.13 (~RESET)
ROW0: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), D16.1 (K), D20.1 (K), D23.1 (K), D27.1 (K), D31.1 (K), D34.1 (K), D38.1 (K), D41.1 (K), D45.1 (K), D49.1 (K), U1.8 (PB0)
ROW1: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), D17.1 (K), D21.1 (K), D24.1 (K), D28.1 (K), D32.1 (K), D35.1 (K), D39.1 (K), D42.1 (K), D46.1 (K), D50.1 (K), U1.9 (PB1)
ROW2: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), D18.1 (K), D22.1 (K), D25.1 (K), D29.1 (K), D33.1 (K), D36.1 (K), D40.1 (K), D43.1 (K), D47.1 (K), D51.1 (K), U1.22 (PD5)
ROW3: D4.1 (K), D8.1 (K), D12.1 (K), D19.1 (K), D26.1 (K), D30.1 (K), D37.1 (K), D44.1 (K), D48.1 (K), D52.1 (K), U1.12 (PB7)
VCC: C1.1, C2.1, C3.1, C6.1, J1.1 (VBUS), R2.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)

Board: 2 copper layers, 287.0 x 79.0 mm, 119 parts (67 on the bottom side), 81 nets.

## Commit log

2020-05-12 test file
2020-05-12 add fies
2020-05-12 Add submodules
2020-05-12 Add libraries
2020-05-12 Creating the MCU schematic
2020-05-13 The rest of the schematic
2020-05-13 Creating the PCB
2020-05-13 Creating the gerber
2020-05-13 Changed USB connectors
2020-05-24 Finished pcb
